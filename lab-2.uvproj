# Keil uVision project lab-2.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C552 NXP
  cpu: IRAM(0-0xFF) CLOCK(30000000)
  output: lab-2
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.a51
